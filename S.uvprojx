# Keil uVision project S.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CORE;.\HANDWARE;.\SYSTEM;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c
  group HANDWARE
    ./HANDWARE/: adc.c bsp_key.c bsp_relay.c oled.c infrared.c dht11.c rtc.c board_config .c myiic.c oledfont.h
  group CORE
    ./CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group SYSTEM
    ./SYSTEM/: delay.c usart.c sys.c
